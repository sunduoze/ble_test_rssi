# Keil uVision project ble_app_scan.uvprojx, settings and files
target IK-52840DK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: nRF52840-qaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\components;..\..\components\boards;..\..\components\ble\ble_db_discovery;..\..\components\ble\common;..\..\components\ble\nrf_ble_qwr;..\..\components\ble\nrf_ble_scan;..\..\components\ble\nrf_ble_gatt;..\..\components\ble\nrf_ble_gq;..\..\components\libraries\bsp;..\..\components\libraries\balloc;..\..\components\libraries\atomic;..\..\components\libraries\atomic_fifo;..\..\components\libraries\atomic_flags;..\..\components\libraries\button;..\..\components\libraries\crc16;..\..\components\libraries\delay;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\experimental_task_manager;..\..\components\libraries\fds;..\..\components\libraries\fstorage;..\..\components\libraries\gfx;..\..\components\libraries\gpiote;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\mem_manager;..\..\components\libraries\hardfault;..\..\components\libraries\util;..\..\components\libraries\strerror;..\..\components\libraries\timer;..\..\components\libraries\svc;..\..\components\softdevice\common;..\..\components\softdevice\s140\headers;..\..\components\softdevice\s140\headers\nrf52;..\..\components\libraries\memobj;..\..\components\libraries\queue;..\..\components\libraries\ringbuf;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\scheduler;..\..\components\libraries\mutex;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\fifo;..\..\components\libraries\queue;..\..\components\libraries\uart;..\..\components\libraries\sortlist;..\..\external\fprintf;..\..\external\segger_rtt;..\..\external\utf_converter;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\modules\nrfx\hal;..\..\modules\nrfx\mdk;..\..\modules\nrfx;..\..\modules\nrfx\hal;..\..\modules\nrfx\drivers\include;..\config
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=7 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=7,-DS132,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20002a38 size 0x3d5c8
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ../../app/: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../components/boards/: boards.c
  group Board Support
    ../../components/libraries/bsp/: bsp.c
  group UTF8/UTF16 converter
    ../../external/utf_converter/: utf.c
  group nRF_BLE
    ../../components/ble/common/: ble_advdata.c ble_srv_common.c
    ../../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../components/ble/nrf_ble_gq/: nrf_ble_gq.c
    ../../components/ble/nrf_ble_scan/: nrf_ble_scan.c
  group nRF_Drivers
    ../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../../modules/nrfx/soc/: nrfx_atomic.c
    ../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../components/libraries/button/: app_button.c
    ../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../components/libraries/scheduler/: app_scheduler.c
    ../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../components/libraries/fifo/: app_fifo.c
    ../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../components/libraries/atomic/: nrf_atomic.c
    ../../components/libraries/balloc/: nrf_balloc.c
    ../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../components/libraries/memobj/: nrf_memobj.c
    ../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../components/libraries/queue/: nrf_queue.c
    ../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../components/libraries/sortlist/: nrf_sortlist.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../components/libraries/hardfault/: hardfault_implementation.c
  group nRF_Log
    ../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c nrf_log_backend_uart.c
  group nRF_Segger_RTT
    ../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
target flash_s140_nrf52_7.2.0_softdevice (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: as above
  output: s140_nrf52_7.2.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\config
  asm define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\config
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20002260 size 0x3dda0
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.3.0, Device:Startup 8.35.0
